# Keil uVision project STM32G474_BUCK_BOOST_V1.0.uvprojx, settings and files
target STM32G474_BUCK_BOOST_V1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474_BUCK_BOOST_V1.0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=1,177
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Software/Inc;../BoardDev/Inc;../Lcd/Config;../Lcd/Fonts;../Lcd/GUI_DEV;../Lcd/image;../Lcd/LCD;../Lvgl9;../Lvgl9/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Software
    ../Software/Src/: function.c config_store.c control.c math.c callback.c lv_port_disp.c lv_port_indev.c ui_main.c
    ../Software/Inc/: config.h
  group Application/User/BoardDev
    ../BoardDev/Src/: spiflash.c tmp11x.c
  group Application/User/Lcd
    ../Lcd/Config/: DEV_Config.c
    ../Lcd/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
    ../Lcd/GUI_DEV/: GUI_Paint.c
    ../Lcd/image/: image.c
    ../Lcd/LCD/: LCD_1in69.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c hrtim.c i2c.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/Lvgl/src
    ../Lvgl9/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Lvgl9/src/display/: lv_display.c
    ../Lvgl9/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Lvgl9/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Lvgl9/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../Lvgl9/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Lvgl9/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Lvgl9/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../Lvgl9/src/draw/opengles/: lv_draw_opengles.c
    ../Lvgl9/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../Lvgl9/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Lvgl9/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Lvgl9/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Lvgl9/src/drivers/display/ft81x/: lv_ft81x.c
    ../Lvgl9/src/drivers/display/ili9341/: lv_ili9341.c
    ../Lvgl9/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Lvgl9/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Lvgl9/src/drivers/display/st7735/: lv_st7735.c
    ../Lvgl9/src/drivers/display/st7789/: lv_st7789.c
    ../Lvgl9/src/drivers/display/st7796/: lv_st7796.c
    ../Lvgl9/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Lvgl9/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Lvgl9/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Lvgl9/src/layouts/flex/: lv_flex.c
    ../Lvgl9/src/layouts/grid/: lv_grid.c
    ../Lvgl9/src/layouts/: lv_layout.c
    ../Lvgl9/src/libs/barcode/: code128.c lv_barcode.c
    ../Lvgl9/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Lvgl9/src/libs/bmp/: lv_bmp.c
    ../Lvgl9/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Lvgl9/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Lvgl9/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Lvgl9/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Lvgl9/src/libs/gif/: gifdec.c lv_gif.c
    ../Lvgl9/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Lvgl9/src/libs/libpng/: lv_libpng.c
    ../Lvgl9/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Lvgl9/src/libs/lz4/: lz4.c
    ../Lvgl9/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Lvgl9/src/libs/rle/: lv_rle.c
    ../Lvgl9/src/libs/rlottie/: lv_rlottie.c
    ../Lvgl9/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Lvgl9/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Lvgl9/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Lvgl9/src/: lv_init.c
    ../Lvgl9/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../Lvgl9/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Lvgl9/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Lvgl9/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Lvgl9/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c
    ../Lvgl9/src/others/file_explorer/: lv_file_explorer.c
    ../Lvgl9/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Lvgl9/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Lvgl9/src/others/gridnav/: lv_gridnav.c
    ../Lvgl9/src/others/ime/: lv_ime_pinyin.c
    ../Lvgl9/src/others/imgfont/: lv_imgfont.c
    ../Lvgl9/src/others/monkey/: lv_monkey.c
    ../Lvgl9/src/others/observer/: lv_observer.c
    ../Lvgl9/src/others/snapshot/: lv_snapshot.c
    ../Lvgl9/src/others/sysmon/: lv_sysmon.c
    ../Lvgl9/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Lvgl9/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Lvgl9/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../Lvgl9/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../Lvgl9/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Lvgl9/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Lvgl9/src/stdlib/: lv_mem.c
    ../Lvgl9/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Lvgl9/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Lvgl9/src/themes/default/: lv_theme_default.c
    ../Lvgl9/src/themes/: lv_theme.c
    ../Lvgl9/src/themes/mono/: lv_theme_mono.c
    ../Lvgl9/src/themes/simple/: lv_theme_simple.c
    ../Lvgl9/src/tick/: lv_tick.c
    ../Lvgl9/src/widgets/3dtexture/: lv_3dtexture.c
    ../Lvgl9/src/widgets/animimage/: lv_animimage.c
    ../Lvgl9/src/widgets/arc/: lv_arc.c
    ../Lvgl9/src/widgets/bar/: lv_bar.c
    ../Lvgl9/src/widgets/button/: lv_button.c
    ../Lvgl9/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Lvgl9/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Lvgl9/src/widgets/canvas/: lv_canvas.c
    ../Lvgl9/src/widgets/chart/: lv_chart.c
    ../Lvgl9/src/widgets/checkbox/: lv_checkbox.c
    ../Lvgl9/src/widgets/dropdown/: lv_dropdown.c
    ../Lvgl9/src/widgets/image/: lv_image.c
    ../Lvgl9/src/widgets/imagebutton/: lv_imagebutton.c
    ../Lvgl9/src/widgets/keyboard/: lv_keyboard.c
    ../Lvgl9/src/widgets/label/: lv_label.c
    ../Lvgl9/src/widgets/led/: lv_led.c
    ../Lvgl9/src/widgets/line/: lv_line.c
    ../Lvgl9/src/widgets/list/: lv_list.c
    ../Lvgl9/src/widgets/lottie/: lv_lottie.c
    ../Lvgl9/src/widgets/menu/: lv_menu.c
    ../Lvgl9/src/widgets/msgbox/: lv_msgbox.c
    ../Lvgl9/src/widgets/objx_templ/: lv_objx_templ.c
    ../Lvgl9/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Lvgl9/src/widgets/roller/: lv_roller.c
    ../Lvgl9/src/widgets/scale/: lv_scale.c
    ../Lvgl9/src/widgets/slider/: lv_slider.c
    ../Lvgl9/src/widgets/span/: lv_span.c
    ../Lvgl9/src/widgets/spinbox/: lv_spinbox.c
    ../Lvgl9/src/widgets/spinner/: lv_spinner.c
    ../Lvgl9/src/widgets/switch/: lv_switch.c
    ../Lvgl9/src/widgets/table/: lv_table.c
    ../Lvgl9/src/widgets/tabview/: lv_tabview.c
    ../Lvgl9/src/widgets/textarea/: lv_textarea.c
    ../Lvgl9/src/widgets/tileview/: lv_tileview.c
    ../Lvgl9/src/widgets/win/: lv_win.c
  group Application/User/Lvgl/Conf
    ../Lvgl9/: lv_conf.h lvgl.h lv_version.h
software components: CMSIS:CORE 5.6.0
